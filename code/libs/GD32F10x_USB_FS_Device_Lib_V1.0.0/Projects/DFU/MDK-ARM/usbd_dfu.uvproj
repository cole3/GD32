# Keil uVision project usbd_dfu.uvproj, settings and files
target GD32F103B_USBD_DFU (ARM-ADS)
  device: GD32F10x GigaDevice
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: DFU +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD,USE_GD32F103B_EVAL
  c include: ..\inc;..\..\..\Libraries\GD32_USB_Device_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Library\Core\inc;..\..\..\Libraries\GD32_USB_Device_Library\Class\dfu\inc;..\..\..\Utilities\GD32_EVAL\GD32103B_EVAL;..\..\..\Libraries\CMSIS;..\..\..\Libraries\GD32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../src/: app.c usbd_desc.c usbd_user.c gd32_it.c usb_hwp.c
  group USB_Class
    ../../../Libraries/GD32_USB_Device_Library/Class/dfu/src/: usbd_dfu_core.c usbd_dfu_mal.c usbd_flash_if.c
  group USB_Drivers
    ../../../Libraries/GD32_USB_Device_Driver/src/: usb_buf.c usb_core.c usb_int.c
  group USB_Library
    ../../../Libraries/GD32_USB_Device_Library/Core/src/: usbd_core.c usbd_enum.c usbd_it.c usbd_pwr.c
  group GD32F10X
    ../../../Libraries/StartUp/: startup_gd32f10x_md.s startup_gd32f10x_hd.s
    ../../../Libraries/CMSIS/: system_gd32f10x.c
  group GD32103B-EVAL
    ../../../Utilities/GD32_EVAL/GD32103B_EVAL/: gd32103b_eval.c
  group GD32103C-EVAL
    ../../../Utilities/GD32_EVAL/GD32103C_EVAL/: gd32103c_eval.c
  group GD32103E-EVAL
    ../../../Utilities/GD32_EVAL/GD32103E_EVAL/: gd32103e_eval.c
  group GD32F10X_StdPeriph_Driver
    ../../../Libraries/GD32F10x_StdPeriph_Driver/src/: gd32f10x_dma.c gd32f10x_exti.c gd32f10X_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_pwr.c gd32f10x_rcc.c gd32f10x_sdio.c gd32f10x_spi.c gd32f10x_usart.c
target GD32F103C_USBD_DFU (ARM-ADS)
  device: GD32F10x GigaDevice
  cpu: as above
  output: DFU +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD,USE_GD32F103C_EVAL
  c include: ..\inc;..\..\..\Libraries\GD32_USB_Device_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Library\Core\inc;..\..\..\Libraries\GD32_USB_Device_Library\Class\dfu\inc;..\..\..\Utilities\GD32_EVAL\GD32103C_EVAL;..\..\..\Libraries\CMSIS;..\..\..\Libraries\GD32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32F103E_USBD_DFU (ARM-ADS)
  device: GD32F10x GigaDevice
  cpu: as above
  output: DFU +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_HD,USE_GD32F103E_EVAL
  c include: ..\inc;..\..\..\Libraries\GD32_USB_Device_Driver\inc;..\..\..\Libraries\GD32_USB_Device_Library\Core\inc;..\..\..\Libraries\GD32_USB_Device_Library\Class\dfu\inc;..\..\..\Utilities\GD32_EVAL\GD32103E_EVAL;..\..\..\Libraries\CMSIS;..\..\..\Libraries\GD32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
